# Keil uVision project jz2440.uvproj, settings and files
target jz2440 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: jz2440
  c flags: Optim=1 wLevel=2
  c include: ..\..\libcpu\s3c2440
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x100000 size 0x100000
  memory RVCT9: RAM 0x40000000 size 0x1000
  group board
    ./: startup.c led.c
  group libcpu
    ../../libcpu/s3c2440/: start_mdk.S uart.c clock.c
